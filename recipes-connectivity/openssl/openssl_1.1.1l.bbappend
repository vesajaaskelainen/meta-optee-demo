FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-openssl.cnf-Configure-OP-TEE-for-pkcs11-engine.patch"
